## conf/local.conf
```bitbake
[project]
SECRET_KEY='django-insecure-rnm@ryv2n(w+9w01gd@&uc65997**v)f$^b6#yg*oic9rn@_jz'

[redis]
LOCATION=redis://127.0.0.1:6379/1
PREFIX=DevGuru
LIFETIME = 9660
```
